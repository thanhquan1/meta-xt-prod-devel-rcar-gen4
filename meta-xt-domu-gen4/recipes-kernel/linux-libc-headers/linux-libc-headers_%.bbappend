RENESAS_BSP_URL = "git@github.com:thanhquan1/linux-xen.git"

BRANCH = "dev_2.5Gbps.rc1"
SRCREV = "${AUTOREV}"
LINUX_VERSION = "5.10.41"
